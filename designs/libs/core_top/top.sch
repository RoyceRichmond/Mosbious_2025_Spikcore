v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {designs/libs/core_AH_neuron_arr/AH_neuron_arr.sym} 180 10 0 0 {name=x1}
C {designs/libs/core_LIF_ring/LIF.sym} 350 -220 0 0 {name=x2}
