v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1640 -1000 2440 -800 {flags=graph
y1=-0.0017
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="vin
phi_1
reward"
color="4 8 6"
dataset=-1
unitx=1
logx=0
logy=0
legend=1}
B 2 1640 -800 2440 -600 {flags=graph
y1=-0.0017
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="phi_1
phi_2
phi_2b"
color="8 6 12"
dataset=-1
unitx=1
logx=0
logy=0
legend=1}
B 2 1640 -600 2440 -400 {flags=graph
y1=-0.0017
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node="phi_int
phi_fire"
color="4 7"
dataset=-1
unitx=1
logx=0
logy=0
legend=1}
B 2 1640 -400 2440 0 {flags=graph
y1=0.049
y2=3.4
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=3e-05
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=vspike
color=10
dataset=-1
unitx=1
logx=0
logy=0
}
N 460 -850 480 -850 {lab=vin}
N 660 -710 680 -710 {lab=vss}
N 680 -710 680 -680 {lab=vss}
N 660 -680 680 -680 {lab=vss}
N 660 -680 660 -660 {lab=vss}
N 760 -860 800 -860 {lab=vneg}
N 460 -870 480 -870 {lab=vneg}
N 460 -940 460 -870 {lab=vneg}
N 460 -940 780 -940 {lab=vneg}
N 780 -940 780 -860 {lab=vneg}
N 580 -860 580 -780 {lab=#net1}
N 580 -780 590 -780 {lab=#net1}
N 650 -780 660 -780 {lab=#net2}
N 660 -860 660 -780 {lab=#net2}
N 660 -780 660 -740 {lab=#net2}
N 1000 -850 1020 -850 {lab=phi_1}
N 1200 -710 1220 -710 {lab=vss}
N 1220 -710 1220 -680 {lab=vss}
N 1200 -680 1220 -680 {lab=vss}
N 1200 -680 1200 -660 {lab=vss}
N 1300 -860 1340 -860 {lab=#net3}
N 1000 -870 1020 -870 {lab=#net3}
N 1000 -940 1000 -870 {lab=#net3}
N 1000 -940 1320 -940 {lab=#net3}
N 1320 -940 1320 -860 {lab=#net3}
N 1120 -860 1120 -780 {lab=#net4}
N 1120 -780 1130 -780 {lab=#net4}
N 1190 -780 1200 -780 {lab=#net5}
N 1200 -860 1200 -780 {lab=#net5}
N 1200 -780 1200 -740 {lab=#net5}
N 900 -860 920 -860 {lab=phi_1}
N 920 -860 920 -850 {lab=phi_1}
N 920 -850 1000 -850 {lab=phi_1}
N 630 -540 730 -540 {lab=phi_int}
N 650 -550 650 -540 {lab=phi_int}
N 650 -250 710 -250 {lab=#net6}
N 850 -230 910 -230 {lab=vrefrac}
N 740 -390 740 -370 {lab=vss}
N 710 -370 710 -330 {lab=#net6}
N 710 -330 740 -330 {lab=#net6}
N 680 -370 680 -250 {lab=#net6}
N 680 -370 710 -370 {lab=#net6}
N 770 -370 880 -370 {lab=vrefrac}
N 880 -370 880 -230 {lab=vrefrac}
N 580 -290 590 -290 {lab=vspike_down}
N 540 -290 580 -290 {lab=vspike_down}
N 570 -250 620 -250 {lab=vspike_down}
N 570 -290 570 -250 {lab=vspike_down}
N 650 -290 650 -250 {lab=#net6}
N 540 -170 590 -170 {lab=vneg}
N 570 -210 620 -210 {lab=vneg}
N 570 -210 570 -170 {lab=vneg}
N 650 -210 650 -170 {lab=#net7}
N 650 -210 710 -210 {lab=#net7}
N 620 -330 620 -290 {lab=vss}
N 620 -170 620 -130 {lab=vss}
N 680 -210 680 -140 {lab=#net7}
N 680 -140 720 -140 {lab=#net7}
N 720 -140 720 -130 {lab=#net7}
N 680 -140 680 -100 {lab=#net7}
N 720 -100 730 -100 {lab=vss}
N 730 -100 730 -70 {lab=vss}
N 720 -70 730 -70 {lab=vss}
N 730 -100 750 -100 {lab=vss}
N 1020 -360 1050 -360 {lab=vref}
N 1300 -360 1330 -360 {lab=vrefrac}
N 1140 -360 1210 -360 {lab=vspike}
N 1170 -500 1170 -360 {lab=vspike}
N 1020 -520 1170 -520 {lab=vspike}
N 1170 -520 1170 -500 {lab=vspike}
N 1170 -520 1210 -520 {lab=vspike}
N 1300 -520 1330 -520 {lab=#net8}
C {designs/libs/core_LIF_comp/core_not/not.sym} 500 -870 0 0 {name=x2}
C {title.sym} 160 0 0 0 {name=l1 author="Oscar Islas"}
C {lab_pin.sym} 460 -850 0 0 {name=p10 sig_type=std_logic lab=vin}
C {lab_pin.sym} 500 -900 2 0 {name=p13 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 640 -710 0 0 {name=M2
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {designs/libs/core_LIF_comp/core_nand/nand.sym} 520 -860 0 0 {name=x13}
C {designs/libs/core_LIF_comp/core_not/not.sym} 640 -870 0 0 {name=x14}
C {lab_pin.sym} 680 -900 2 0 {name=p84 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 820 -900 2 0 {name=p85 sig_type=std_logic lab=vdd}
C {vsource.sym} 60 -560 0 1 {name=V1 value="pulse(2 0 -4u 1n 1n 5u 8u)" savecurrent=false}
C {gnd.sym} 60 -530 0 0 {name=l5 lab=GND}
C {lab_pin.sym} 60 -590 0 1 {name=p86 sig_type=std_logic lab=vin}
C {vsource.sym} 160 -760 0 1 {name=V2 value=3.3 savecurrent=false}
C {gnd.sym} 160 -730 0 0 {name=l6 lab=GND}
C {lab_pin.sym} 160 -790 0 1 {name=p87 sig_type=std_logic lab=vdd}
C {symbols/cap_mim_2f0fF.sym} 620 -780 3 0 {name=C2
W=1e-6
L=1e-6
model=cap_mim_2f0fF
spiceprefix=X
m=2}
C {lab_pin.sym} 500 -820 2 0 {name=p11 sig_type=std_logic lab=vss}
C {lab_pin.sym} 680 -820 2 0 {name=p12 sig_type=std_logic lab=vss}
C {lab_pin.sym} 820 -820 2 0 {name=p14 sig_type=std_logic lab=vss}
C {lab_pin.sym} 660 -660 2 0 {name=p15 sig_type=std_logic lab=vss}
C {lab_pin.sym} 620 -710 2 1 {name=p16 sig_type=std_logic lab=vres}
C {vsource.sym} 160 -660 0 1 {name=V3 value=0.5 savecurrent=false}
C {gnd.sym} 160 -630 0 0 {name=l2 lab=GND}
C {lab_pin.sym} 160 -690 0 1 {name=p17 sig_type=std_logic lab=vres}
C {lab_pin.sym} 920 -860 2 0 {name=p53 sig_type=std_logic lab=phi_1}
C {launcher.sym} 1470 -230 0 0 {name=h5
descr="load waves" 
tclcommand="xschem raw_read $netlist_dir/tb_phaseUpulse.raw tran"
}
C {devices/code_shown.sym} 65 -460 0 0 {name=s1 only_toplevel=false value="
.option method=gear seed=12
.control
    tran 1n 30u
    write tb_phaseUpulse_v2.raw
.endc
.save all
"
spice_ignore=False}
C {devices/code_shown.sym} 0 -200 0 0 {name=MODELS1 only_toplevel=true
format="tcleval( @value )"
value="
.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
"}
C {gnd.sym} 60 -730 0 0 {name=l3 lab=GND}
C {lab_pin.sym} 60 -790 0 1 {name=p1 sig_type=std_logic lab=vss}
C {vsource.sym} 60 -760 0 1 {name=V4 value=0 savecurrent=false}
C {vsource.sym} 160 -560 0 1 {name=V5 value=1.5 savecurrent=false}
C {gnd.sym} 160 -530 0 0 {name=l4 lab=GND}
C {lab_pin.sym} 160 -590 0 1 {name=p52 sig_type=std_logic lab=vref}
C {vsource.sym} 260 -760 0 1 {name=V6 value=1.2 savecurrent=false}
C {gnd.sym} 260 -730 0 0 {name=l7 lab=GND}
C {lab_pin.sym} 260 -790 0 1 {name=p54 sig_type=std_logic lab=vspike_down}
C {vsource.sym} 260 -660 0 1 {name=V7 value=2.5 savecurrent=false}
C {gnd.sym} 260 -630 0 0 {name=l8 lab=GND}
C {lab_pin.sym} 260 -690 0 1 {name=p55 sig_type=std_logic lab=vspike_up}
C {vsource.sym} 260 -560 0 1 {name=V8 value=3 savecurrent=false}
C {gnd.sym} 260 -530 0 0 {name=l9 lab=GND}
C {lab_pin.sym} 260 -590 0 1 {name=p56 sig_type=std_logic lab=vspike_up_plus}
C {vsource.sym} 60 -660 0 1 {name=V9 value="pulse(0 3.3 20u 1n 1n 20u 40u)" savecurrent=false}
C {gnd.sym} 60 -630 0 0 {name=l10 lab=GND}
C {lab_pin.sym} 60 -690 0 1 {name=p57 sig_type=std_logic lab=reward}
C {designs/libs/core_LIF_comp/core_not/not.sym} 1040 -870 0 0 {name=x1}
C {lab_pin.sym} 1040 -900 2 0 {name=p3 sig_type=std_logic lab=vdd}
C {symbols/nfet_03v3.sym} 1180 -710 0 0 {name=M1
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {designs/libs/core_LIF_comp/core_nand/nand.sym} 1060 -860 0 0 {name=x3}
C {designs/libs/core_LIF_comp/core_not/not.sym} 1180 -870 0 0 {name=x4}
C {lab_pin.sym} 1220 -900 2 0 {name=p4 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1360 -900 2 0 {name=p5 sig_type=std_logic lab=vdd}
C {symbols/cap_mim_2f0fF.sym} 1160 -780 3 0 {name=C1
W=1e-6
L=1e-6
model=cap_mim_2f0fF
spiceprefix=X
m=2}
C {lab_pin.sym} 1040 -820 2 0 {name=p6 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1220 -820 2 0 {name=p7 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1360 -820 2 0 {name=p8 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1200 -660 2 0 {name=p9 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1160 -710 2 1 {name=p18 sig_type=std_logic lab=vres}
C {lab_pin.sym} 1440 -860 2 0 {name=p19 sig_type=std_logic lab=phi_2}
C {designs/libs/core_LIF_comp/core_not/not.sym} 570 -550 0 0 {name=x19}
C {designs/libs/core_LIF_comp/core_nor/nor.sym} 580 -460 0 0 {name=x21}
C {lab_pin.sym} 550 -580 2 0 {name=p89 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 750 -580 2 0 {name=p99 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 650 -550 2 0 {name=p100 sig_type=std_logic lab=phi_int}
C {lab_pin.sym} 550 -500 2 0 {name=p101 sig_type=std_logic lab=vss}
C {lab_pin.sym} 750 -500 2 0 {name=p107 sig_type=std_logic lab=vss}
C {lab_pin.sym} 540 -550 2 1 {name=p108 sig_type=std_logic lab=phi_1}
C {lab_pin.sym} 540 -530 2 1 {name=p109 sig_type=std_logic lab=phi_2}
C {lab_pin.sym} 830 -540 2 0 {name=p110 sig_type=std_logic lab=phi_fire}
C {lab_pin.sym} 780 -940 2 0 {name=p2 sig_type=std_logic lab=vneg}
C {designs/libs/core_LIF_comp/core_ota_1stage/ota_1stage.sym} 750 -230 0 0 {name=x22}
C {lab_pin.sym} 910 -230 2 0 {name=p111 sig_type=std_logic lab=vrefrac}
C {lab_pin.sym} 540 -290 0 0 {name=p113 sig_type=std_logic lab=vspike_down}
C {lab_pin.sym} 730 -290 2 0 {name=p116 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 730 -170 2 0 {name=p117 sig_type=std_logic lab=vss}
C {symbols/nfet_03v3.sym} 740 -350 3 0 {name=M9
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 740 -390 1 0 {name=p123 sig_type=std_logic lab=vss}
C {symbols/nfet_03v3.sym} 620 -270 3 0 {name=M10
L=0.5u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 620 -190 3 1 {name=M11
L=3u
W=0.4u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/nfet_03v3.sym} 700 -100 0 0 {name=M12
L=0.28u
W=1.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {lab_pin.sym} 750 -100 2 0 {name=p124 sig_type=std_logic lab=vss}
C {lab_pin.sym} 620 -130 1 1 {name=p125 sig_type=std_logic lab=vss}
C {lab_pin.sym} 540 -170 2 1 {name=p122 sig_type=std_logic lab=vneg}
C {lab_pin.sym} 620 -330 3 1 {name=p20 sig_type=std_logic lab=vss}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1260 -400 0 0 {name=x7}
C {lab_pin.sym} 1230 -560 1 0 {name=p82 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1280 -480 2 0 {name=p83 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1260 -480 0 0 {name=p88 sig_type=std_logic lab=phi_1}
C {lab_pin.sym} 1020 -360 2 1 {name=p90 sig_type=std_logic lab=vref}
C {lab_pin.sym} 1020 -520 0 0 {name=p91 sig_type=std_logic lab=vspike}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1090 -240 0 1 {name=x10}
C {lab_pin.sym} 1120 -400 3 1 {name=p92 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1070 -320 2 1 {name=p93 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1090 -320 0 1 {name=p94 sig_type=std_logic lab=phi_int}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1250 -240 0 1 {name=x18}
C {lab_pin.sym} 1280 -400 3 1 {name=p95 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1230 -320 2 1 {name=p96 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1250 -320 0 1 {name=p97 sig_type=std_logic lab=phi_2}
C {lab_pin.sym} 1330 -360 2 0 {name=p98 sig_type=std_logic lab=vrefrac}
C {designs/libs/core_LIF_comp/core_conmutator/conmutator.sym} 1420 -360 0 1 {name=x20}
C {lab_pin.sym} 1420 -560 2 0 {name=p102 sig_type=std_logic lab=vdd}
C {lab_pin.sym} 1420 -450 2 0 {name=p103 sig_type=std_logic lab=vss}
C {lab_pin.sym} 1480 -510 2 0 {name=p104 sig_type=std_logic lab=vspike_up_plus}
C {lab_pin.sym} 1480 -530 2 0 {name=p105 sig_type=std_logic lab=vspike_up}
C {lab_pin.sym} 1480 -490 2 0 {name=p106 sig_type=std_logic lab=reward}
