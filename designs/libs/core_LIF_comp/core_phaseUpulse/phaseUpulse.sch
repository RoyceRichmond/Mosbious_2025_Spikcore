v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {designs/libs/core_LIF_comp/core_monostable/monostable.sym} 10 -10 0 0 {name=x1}
C {designs/libs/core_LIF_comp/core_not/not.sym} 50 -80 0 0 {name=x2}
C {designs/libs/core_LIF_comp/core_not/not.sym} 220 -80 0 0 {name=x3}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1120 -260 0 0 {name=x4}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1140 -110 0 0 {name=x5}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1010 100 0 0 {name=x6}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 1000 290 0 0 {name=x7}
C {designs/libs/core_LIF_comp/core_switch/switch.sym} 720 470 0 0 {name=x8}
C {designs/libs/core_LIF_comp/core_not/not.sym} 700 620 0 0 {name=x9}
C {designs/libs/core_LIF_comp/core_not/not.sym} -140 340 0 0 {name=x10}
C {designs/libs/core_LIF_comp/core_ota_2stage/ota_2stage.sym} 700 620 0 0 {name=x11}
